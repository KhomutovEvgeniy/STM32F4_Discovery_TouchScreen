# Keil uVision project dummy.uvproj, settings and files
target NoTests (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rcu +hex
  BeforeMake: .\src\retarget\update_commit_hash.bat
  AfterMake: .\src\retarget\remove_commit_hash.bat
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER, USE_FULL_ASSERT,  __FPU_PRESENT, __STDC_LIMIT_MACROS, USE_HSE, STM32F407xx, STM32F40_41xxx, HSE_VALUE=8000000
  c misc: --feedback=unused_func
  c include: .\src;.\src\mcu_support_package\inc;.\src\cmsis;.\src\STM32F4xx_StdPeriph_Driver\inc;.\src\STM32F4-Discovery;.\src\main
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --feedback=unused_func
  group common_functions
    ./src/Common_Functions/: common_functions.cpp common_functions.h
  group main
    ./src/Main/: main.cpp
    ./src/: project_config.h
    ./src/main/: STMPE811QTR.c TouchPoint.c LCD_Touch_Calibration.c
    ./src/STM32F4-Discovery/: fonts.c stm32f4_discovery.c stm32f4_discovery_lcd.c
  group mcu_support_package
    ./src/mcu_support_package/: system_stm32f4xx.c
    ./src/mcu_support_package/arm/: startup_stm32f401xc.s startup_stm32f401xe.s startup_stm32f405xx.s startup_stm32f407xx.s startup_stm32f410cx.s startup_stm32f410rx.s startup_stm32f410tx.s startup_stm32f411xe.s startup_stm32f412cx.s startup_stm32f412rx.s startup_stm32f412vx.s startup_stm32f412zx.s startup_stm32f413xx.s startup_stm32f415xx.s startup_stm32f417xx.s startup_stm32f423xx.s startup_stm32f427xx.s startup_stm32f429xx.s startup_stm32f437xx.s startup_stm32f439xx.s startup_stm32f446xx.s startup_stm32f469xx.s startup_stm32f479xx.s
  group retarget
    ./src/retarget/: retarget.cpp
  group STM32F4xx_StdPeriph_Driver
    ./src/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_sdio.c
